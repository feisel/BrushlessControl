# Keil uVision project c++Lib.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC1317 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IRAM2(0x20000000-0x200007FF) IROM(0-0xFFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: c++Lib
  c flags: Optim=1
  c misc: --feedback=unused.txt
  c include: ..\lpc13xxCodeBase
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x10000000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x800
  link misc: --feedback=unused.txt
  group Source Group 1
    ./: main.cpp lpc13.cpp lpc13I2C.cpp Lpc13Pin.cpp Lpc13Timer.cpp SSPSoftware.cpp startup_LPC13Uxx.s system_LPC13Uxx.c Lpc13PWM.cpp
  group sensors
    ./drivers/sensors/: LM75.cpp
  group rf
    ./drivers/rf/: rfm70.cpp
